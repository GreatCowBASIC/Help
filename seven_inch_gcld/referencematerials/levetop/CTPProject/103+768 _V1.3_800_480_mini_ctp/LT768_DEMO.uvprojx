# Keil uVision project LT768_DEMO.uvprojx, settings and files
target SMT32F103RCT6_LT768_App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SMT32F103RCT6_LT768_App +hex
  AfterMake: fromelf.exe --bin -o ./Output/bin/@L.bin  ./Output/OBJ/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\IF_PORT;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\LT768;.\HARDWARE\LT768_Demo;.\HARDWARE\LT768_Lib;.\HARDWARE\rtp;.\HARDWARE\rpio;.\HARDWARE\GT911
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./USER/: main.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LT768/: LT768.c
    ./HARDWARE/IF_PORT/: if_port.c
    ./HARDWARE/LT768_Lib/: LT768_Lib.c
    ./HARDWARE/rtp/: rtp.c
    ./HARDWARE/rpio/: rpio.c
    ./HARDWARE/GT911/: gt911.c
    ./HARDWARE/LT768_Demo/: LT768_Demo.c
  group Core
    ./USER/: system_stm32f10x.c
    ./CORE/: STM32F10x.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c
software components: CMSIS:CORE 5.1.1

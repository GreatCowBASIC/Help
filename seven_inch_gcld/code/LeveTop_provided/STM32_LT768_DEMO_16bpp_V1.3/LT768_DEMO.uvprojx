# Keil uVision project LT768_DEMO.uvprojx, settings and files
target LT768_DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LT768_DEMO +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\USER;.\HARDWARE\IF_PORT;.\HARDWARE\KEY;.\HARDWARE\LCD;.\HARDWARE\LED;.\HARDWARE\LT768;.\HARDWARE\LT768_Demo;.\HARDWARE\LT768_Lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./USER/: main.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HARDWARE
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/LT768/: LT768.c
    ./HARDWARE/IF_PORT/: if_port.c
    ./HARDWARE/LT768_Lib/: LT768_Lib.c
    ./HARDWARE/LT768_Demo/: LT768_Demo.c
  group Core
    ./USER/: system_stm32f10x.c
    ./CORE/: STM32F10x.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
software components: CMSIS:CORE 5.1.1
